Commit message: aruco urdf, init cam2

File: src/urdf_models/robot_pami.urdf (robot description, URDF)
Before this commit: robot robot_rectangle, 1 links, 0 joints
Links:
- link base: geometry collision mesh filename=pami.obj; visual mesh filename=pami.obj
