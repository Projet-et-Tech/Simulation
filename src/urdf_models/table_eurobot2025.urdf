Commit message: calibrations & detection depuis clic

File: src/urdf_models/table_eurobot2025.urdf (robot description, URDF)
Before this commit: robot obj_model, 8 links, 7 joints
Links:
- added link world
Joints:
- added joint world_to_base_link: type fixed, parent world, child table_base
